# IAR project Pilot_LPC54608.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512ET180 NXP LPC54608J512ET180
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; LWIP_RAW=1; FSL_RTOS_FREE_RTOS; MBEDTLS_CONFIG_FILE="lpc_mbedtls_config.h"
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.PreInclude: devices\LPC54608\utilities\fsl_debug_console.h
  ICCARM.CCIncludePath2: ; apps\LCD; apps\GUI; apps\mqtt_app; apps\fatfs; board; freertos\portable\IAR\ARM_CM4F; freertos\include; CMSIS\include; devices; devices\LPC54608; middleware\lwip_2.0.0\port; middleware\lwip_2.0.0\src; middleware\lwip_2.0.0\src\include; middleware\lwip_2.0.0\contrib\apps; middleware\emWin_5.38\emWin_header; middleware\emWin_5.38\emWin_Config; middleware\paho_mqtt; middleware\paho_mqtt\MQTTPacket; middleware\paho_mqtt\FreeRTOS; middleware\wiced_mqtt; middleware\mbedtls\include; middleware\mbedtls\port; middleware\fatfs_0.12b\src; middleware\fatfs_0.12b\src\fsl_sd_disk; middleware\sdmmc_2.1.2\inc; middleware\sdmmc_2.1.2\port; freertos\Source; devices\LPC54608\drivers; devices\LPC54608\utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: Pilot_LPC54608.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: LPC54608J512_flash.icf
  ILINK.IlinkAdditionalLibs: middleware\emwin_5.38\emWin_library\IAR\emWin_M4F.a; devices\LPC54608\iar\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_flash_app (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; LWIP_RAW=1; FSL_RTOS_FREE_RTOS; MQTT_TASK
  ICCARM.CCIncludePath2: ; apps\LCD; apps\GUI; apps\mqtt_app; apps\fatfs; board; freertos\portable\IAR\ARM_CM4F; freertos\include; CMSIS\include; devices; devices\LPC54608; middleware\lwip_2.0.0\port; middleware\lwip_2.0.0\src; middleware\lwip_2.0.0\src\include; middleware\lwip_2.0.0\contrib\apps; middleware\emWin_5.38\emWin_header; middleware\emWin_5.38\emWin_Config; middleware\paho_mqtt; middleware\paho_mqtt\MQTTPacket; middleware\paho_mqtt\FreeRTOS; middleware\fatfs_0.12b\src; middleware\fatfs_0.12b\src\fsl_sd_disk; middleware\sdmmc_2.1.2\inc; middleware\sdmmc_2.1.2\port; freertos\Source; devices\LPC54608\drivers; devices\LPC54608\utilities
  OBJCOPY.OOCOutputFile: Pilot_LPC54608_flash_app.bin
  ILINK.IlinkIcfFile: LPC54608J512_flash_app.icf
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; LWIP_RAW=1; FSL_RTOS_FREE_RTOS; MQTT_TASK; MBEDTLS_CONFIG_FILE="lpc_mbedtls_config.h"
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
configuration ssl_mqtt_debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC54S608J512ET180 NXP LPC54S608J512ET180
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; LWIP_RAW=1; FSL_RTOS_FREE_RTOS; MQTT_TASK; MBEDTLS_CONFIG_FILE="lpc54608_mbedtls.h"; LWIP_POSIX_SOCKETS_IO_NAMES=1; MQTT_USE_TLS
  ICCARM.CCIncludePath2: ; apps\LCD; apps\GUI; apps\mqtt_app; apps\fatfs; board; freertos\portable\IAR\ARM_CM4F; freertos\include; CMSIS\include; devices; devices\LPC54608; middleware\lwip_2.0.0\port; middleware\lwip_2.0.0\src; middleware\lwip_2.0.0\src\include; middleware\lwip_2.0.0\contrib\apps; middleware\emWin_5.38\emWin_header; middleware\emWin_5.38\emWin_Config; middleware\paho_mqtt; middleware\paho_mqtt\MQTTPacket; middleware\paho_mqtt\FreeRTOS; middleware\paho_mqtt\SSL; middleware\wiced_mqtt; middleware\mbedtls-2.6.0\include; middleware\mbedtls-2.6.0\port\LPC54608; middleware\fatfs_0.12b\src; middleware\fatfs_0.12b\src\fsl_sd_disk; middleware\sdmmc_2.1.2\inc; middleware\sdmmc_2.1.2\port; freertos\Source; devices\LPC54608\drivers; devices\LPC54608\utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration SSL_MQTT_NO_TASK (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; LWIP_RAW=1; FSL_RTOS_FREE_RTOS; MBEDTLS_CONFIG_FILE="lpc54608_mbedtls.h"; LWIP_POSIX_SOCKETS_IO_NAMES=1; MQTT_USE_TLS
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: FreeRTOSConfig.h LPC54608J512_flash.icf LPC54608J512_flash_app.icf main.c
  group apps/fatfs
    apps/fatfs/: ffconf.h sd_fatfs.c sd_fatfs.h
  group apps/GUI
    apps/GUI/: app_gui.c app_gui.h
  group apps/LCD
    apps/LCD/: app_lcd.c app_lcd.h
  group apps/lwip_ping
    middleware/lwip_2.0.0/contrib/apps/ping/: ping.c ping.h
  group apps/mqtt_app
    apps/mqtt_app/: MQTTEcho.c
  group board
    board/: board.c board.h clock_config.c clock_config.h fsl_phy.c fsl_phy.h pin_mux.c pin_mux.h
  group drivers
    devices/LPC54608/drivers/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_ctimer.c fsl_ctimer.h fsl_dma.c fsl_dma.h fsl_dmic.c fsl_dmic.h fsl_dmic_dma.c fsl_dmic_dma.h fsl_eeprom.c fsl_eeprom.h fsl_emc.c fsl_emc.h fsl_enet.c fsl_enet.h fsl_flashiap.c fsl_flashiap.h fsl_flexcomm.c fsl_flexcomm.h fsl_fmc.c fsl_fmc.h fsl_fmeas.c fsl_fmeas.h fsl_gint.c fsl_gint.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_dma.c fsl_i2c_dma.h fsl_i2c_freertos.c fsl_i2c_freertos.h fsl_i2s.c fsl_i2s.h fsl_i2s_dma.c fsl_i2s_dma.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_lcdc.c fsl_lcdc.h fsl_mcan.c fsl_mcan.h fsl_mrt.c fsl_mrt.h fsl_otp.h fsl_pint.c fsl_pint.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_rit.c fsl_rit.h fsl_rng.h fsl_rtc.c fsl_rtc.h fsl_sctimer.c fsl_sctimer.h fsl_sdif.c fsl_sdif.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_spi_freertos.c fsl_spi_freertos.h fsl_spifi.c fsl_spifi.h fsl_spifi_dma.c fsl_spifi_dma.h fsl_usart.c fsl_usart.h fsl_usart_dma.c fsl_usart_dma.h fsl_usart_freertos.c fsl_usart_freertos.h fsl_utick.c fsl_utick.h fsl_wwdt.c fsl_wwdt.h
  group freertos
    freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    freertos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    freertos/portable/MemMang/: heap_3.c
  group freertos/portable
    freertos/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
  group middleware
    apps/mqtt_app/: MQTTEcho.h
  group middleware/emwin
    middleware/emwin_5.38/emWin_header/: GUI.h
    middleware/emwin_5.38/emWin_Config/: GUIConf.h
  group middleware/fatfs/fatfs_include
    middleware/fatfs_0.12b/src/: diskio.h ff.h integer.h
    middleware/fatfs_0.12b/src/fsl_sd_disk/: fsl_sd_disk.h
  group middleware/fatfs/fatfs_source
    middleware/fatfs_0.12b/src/: diskio.c ff.c
    middleware/fatfs_0.12b/src/fsl_sd_disk/: fsl_sd_disk.c
  group middleware/lwip/port
    middleware/lwip_2.0.0/port/: ethernetif.c ethernetif.h lwipopts.h sys_arch.c
  group middleware/lwip/port/arch
    middleware/lwip_2.0.0/port/arch/: cc.h perf.h sys_arch.h
  group middleware/lwip/src/api
    middleware/lwip_2.0.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group middleware/lwip/src/core
    middleware/lwip_2.0.0/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group middleware/lwip/src/core/ipv4
    middleware/lwip_2.0.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group middleware/lwip/src/core/ipv6
    middleware/lwip_2.0.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group middleware/lwip/src/include/lwip
    middleware/lwip_2.0.0/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group middleware/lwip/src/include/lwip/priv
    middleware/lwip_2.0.0/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group middleware/lwip/src/include/lwip/prot
    middleware/lwip_2.0.0/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group middleware/lwip/src/include/netif
    middleware/lwip_2.0.0/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group middleware/lwip/src/include/netif/ppp
    middleware/lwip_2.0.0/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group middleware/lwip/src/include/netif/ppp/polarssl
    middleware/lwip_2.0.0/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group middleware/lwip/src/netif
    middleware/lwip_2.0.0/src/netif/: ethernet.c lowpan6.c slipif.c
  group middleware/lwip/src/netif/ppp
    middleware/lwip_2.0.0/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group middleware/mbedtls/include
    middleware/mbedtls-2.6.0/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group middleware/mbedtls/library
    middleware/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group middleware/mbedtls/port
    middleware/mbedtls-2.6.0/port/lpc54608/: lpc54608_mbedtls.c lpc54608_mbedtls.h threading_alt.c threading_alt.h
  group middleware/paho_mqtt
    middleware/paho_mqtt/: MQTTClient.c MQTTClient.h
  group middleware/paho_mqtt/certs
    middleware/paho_mqtt/SSL/certs/: client_cer.c privkey_cer.c resources.h rootca_cer.c
  group middleware/paho_mqtt/freeRTOS
    middleware/paho_mqtt/FreeRTOS/: MQTTFreeRTOS.c MQTTFreeRTOS.h
  group middleware/paho_mqtt/MQTTPacket
    middleware/paho_mqtt/MQTTPacket/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group middleware/paho_mqtt/SSL
    middleware/paho_mqtt/SSL/: net_sockets.c ssl_mqtt.c ssl_mqtt.h
  group middleware/sdmmc/inc
    middleware/sdmmc_2.1.2/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
  group middleware/sdmmc/port
    middleware/sdmmc_2.1.2/port/sdif/freertos/: event.c fsl_host.c
    middleware/sdmmc_2.1.2/port/: event.h
  group middleware/sdmmc/src
    middleware/sdmmc_2.1.2/src/: fsl_sd.c fsl_sdmmc.c
  group startup
    devices/LPC54608/iar/: startup_LPC54608.s
    devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group Utilities
    devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
